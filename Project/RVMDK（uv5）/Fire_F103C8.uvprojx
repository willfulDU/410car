# Keil uVision project Fire_F103C8.uvprojx, settings and files
target can (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\can;..\..\User\ws2812b;..\..\User\pedal;..\..\User\vl53l0\core\inc;..\..\User\vl53l0\demo;..\..\User\vl53l0\platform\inc;..\..\User\motor;..\..\User\turn;..\..\User\oled;..\..\User\SysTick;..\..\User\si24r1\drv_mcu\inc;..\..\User\si24r1\drv_periph\inc;..\..\User\wheel;..\..\User\switch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c main.h
    ../../User/usart/: bsp_usart.c
    ../../User/ws2812b/: ws2812b.c
    ../../User/pedal/: pedal.c
    ../../User/vl53l0/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../User/vl53l0/demo/: vl53l0x.c
    ../../User/vl53l0/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../../User/motor/: motor.c
    ../../User/turn/: turn.c
    ../../User/oled/: oled.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/si24r1/drv_mcu/src/: drv_delay.c drv_gpio.c drv_spi.c
    ../../User/si24r1/drv_periph/src/: drv_RF24L01.c
    ../../User/wheel/: wheel.c
    ../../User/switch/: switch.c
  group DOC
    ../../Doc/: readme.txt
